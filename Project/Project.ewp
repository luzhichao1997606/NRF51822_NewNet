# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51822-QFAB NordicSemi nRF51822-QFAB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NRF51; NRF51822
  ICCARM.CCIncludePath2: ..\Source\App; ..\Source\Hal; ..\Source\Library; ..\Source\Library\nRF_Drivers; ..\Source\components\toolchain; ..\Source\components\toolchain\iar; ..\Source\components\device; ..\Source\components\toolchain\gcc; ..\Source\components\drivers_nrf\hal; ..\Source\components\drivers_nrf\spi_master; ..\Source\components\libraries\util; ..\Source\components\drivers_nrf\config; ..\Source\components\drivers_nrf\nrf_soc_nosd; ..\Source\components\drivers_nrf\common; ..\Source\components\drivers_nrf\clock; ..\Source\components\drivers_nrf\delay; ..\Source\w5500\Ethernet; ..\Source\Rf; ..\Source\components\drivers_nrf\wdt; ..\Source\GPRS; ..\Source\w5500\Ethernet\W5500; ..\Source\w5500\Internet\DHCP; ..\Source\w5500\Internet\DNS; ..\Source\w5500\Internet\MQTT; ..\Source\cJSON; ..\Source\protobuf_c; ..\Source\nrf24l01; ..\Source\components\drivers_nrf\ble_flash; ..\Source\components\drivers_nrf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 4001000726123505.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../DOC/: 说明.txt
  group App
    ../Source/App/: app.c AT_Proc.c main.c mystring.c net.c NetHandler.c nrf_it.c xqueue.c
    ../Source/protobuf_c/protobuf-c/: protobuf-c.c
    ../Source/protobuf_c/: UserInformation.pb-c.c
  group cJSON
    ../Source/cJSON/: cJSON.c cJSON.h
  group Hal
    ../Source/Hal/: hal.c hal.h
  group Library
    ../Source/components/toolchain/iar/: iar_startup_nrf51.s
    ../Source/components/toolchain/: system_nrf51.c
  group Library/nRF_Drivers
    ../Source/components/drivers_nrf/ble_flash/: ble_flash.c
    ../Source/components/drivers_nrf/delay/: nrf_delay.c
    ../Source/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../Source/components/drivers_nrf/common/: nrf_drv_common.c
    ../Source/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../Source/components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../Source/components/drivers_nrf/hal/: nrf_nvmc.c
    ../Source/components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group Library/nRF_Library
    ../Source/components/libraries/util/: app_error.c nrf_assert.c
  group M2M
    ../Source/GPRS/: aes.c aes.h m2m.c m2m.h Uart.c Uart.h
  group NRF24L01
    ../Source/nrf24l01/: nrf24l01+.c
  group nRF_Radio
    ../Source/App/: radio_config.c radio_config.h
  group Rf
    ../Source/Rf/: Radio.c radio.h SPI1.c SPI1.h sx1276.c sx1276.h sx1276_fsk.c sx1276_fsk.h sx1276_hal.c sx1276_hal.h sx1276_lora.c sx1276_lora.h
  group w5500/Ethernet
    ../Source/w5500/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../Source/w5500/Ethernet/W5500/: w5500.c w5500.h
  group w5500/Internet
    ../Source/w5500/Internet/DHCP/: dhcp.c dhcp.h
    ../Source/w5500/Internet/DNS/: dns.c dns.h
  group w5500/Internet/MQTT_APP
    ../Source/w5500/Internet/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
  group w5500/Internet/MQTT_PKG
    ../Source/w5500/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
